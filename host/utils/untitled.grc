options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_fre
  id: variable
  parameters:
    value: 510e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64e3
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    alias: usrp111
    ant0: '"TX/RX"'
    center_freq0: center_fre
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    stream_chans: '[ ]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    alias: usrp112
    ant0: '"TX/RX"'
    center_freq0: center_fre
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    stream_chans: '[ ]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    alias: '0'
    ant0: '"TX/RX"'
    center_freq0: center_fre
    gain0: '0'
    maxoutbuf: '999999999'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_null_sink_0_0, '0']
- [uhd_usrp_source_0_1, '0', blocks_null_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
